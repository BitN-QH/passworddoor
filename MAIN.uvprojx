# Keil uVision project MAIN.uvprojx, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: MAIN +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\AT24C02;.\App\I2C;.\Public;.\App\smg;.\App\stepmotor;.\App\beep;.\App\eeprom;.\App\interrupt;.\App\mainline;.\App\pamanage;.\App\scankey
  group User
    ./User/: main.c
  group App
    ./App/smg/: smg.c
    ./App/stepmotor/: stepmotor.c
    ./App/AT24C02/: 24c02.c
    ./App/I2C/: iic.c
    ./App/scankey/: scankey.c
    ./App/pamanage/: pamanage.c
    ./App/mainline/: mainline.c
    ./App/interrupt/: interrupt.c
    ./App/beep/: beep.c
    ./App/eeprom/: eeprom.c
  group Public
    ./Public/: public.c
